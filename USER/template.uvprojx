# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F042K4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: ..\axf2bin.BAT
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F042,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\FWLIB\inc;..\HARDWARE;..\CORE;..\SYS;..\HARDWARE;..\ZKRT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group USER
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c appgas.c
  group FWLIB
    ../FWLIB/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group HARDWARE
    ../HARDWARE/: can.c led.c rs485.c
  group CORE
    ../CORE/: startup_stm32f042.s
  group SYS
    ../SYS/: usart.c sys.c
  group ZKRT
    ../ZKRT/: zkrt.c guorui.c poison.c
  group DOC
    ../: README.md
    ../document/: yanly_test.txt
